# Keil uVision project main.uvprojx, settings and files
target Example6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_BOARD_LIB CORE_M0
  c include: ..\..\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_11xx;..\..\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_common;..\..\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip;..\..\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_11xx\config_11cxx;..\..\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\applications\lpc11xx\startup_code;.\ff13\source;.\SPI_SD_Card
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ./: main.c
  group startup
    ../../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/: version.txt
    ../../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/applications/lpc11xx/startup_code/: keil_startup_lpc11xx.s sysinit.c
  group lib
    ../../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/software/lpc_core/lpc_chip/chip_common/: fpu_init.c ring_buffer.c
    ../../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/software/lpc_core/lpc_chip/chip_11xx/: acmp_11xx.c adc_11xx.c adc_1125.c chip_11xx.c clock_11xx.c dac_11xx.c gpio_11xx_1.c gpio_11xx_2.c gpiogroup_11xx.c i2c_11xx.c iocon_11xx.c pinint_11xx.c pmu_11xx.c Retarget.c ssp_11xx.c sysctl_11xx.c sysinit_11xx.c timer_11xx.c uart_11xx.c wwdt_11xx.c
  group ff13
    ./ff13/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group sdcard
    ./SPI_SD_Card/: SPI_MSD_Driver.c
software components: CMSIS:CORE 5.0.1
